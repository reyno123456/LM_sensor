# IAR project Backup of Final_Test_V2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 400
  General.SCRStackSize: 200
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: LM018; DEMOBOARD; FINAL_VERSION2
  ICCAVR.CCDiagSuppress: Pa082,Pe167,Pe186
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm644p.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG; LM018; FINAL_VERSION2
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm644ps.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(XDATA)=$EXE_DIR$\Final_Test_V2.eep
  group (top)
    ./: application.c board.c configuration.c dataflash.c decode_scs.c decode_scs_next.c DRI_LCD.c DRI_LCDCHARACTERS.C DRI_TOUCH.C font.c function_modality.c function_service.c global_variable.c IR.c main.c PIR.c printer.c US.c usart.c usb_command.c
