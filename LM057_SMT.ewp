# IAR project LM057_SMT.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: LM057; DEMOBOARD; SMT
  ICCAVR.CCDiagSuppress: Pa082,Pe167,Pe186
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm644ps.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; LM057; SMT
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(XDATA)=$EXE_DIR$\LM057_SMT.eep
  group (top)
    ./: application.c application.h board.c board.h configuration.c configuration.h decode_scs.c decode_scs.h decode_scs_next.c decode_scs_next.h function_modality.c function_modality.h function_service.c function_service.h global_variable.c global_variable.h IR.c IR.h main.c moudle_SCS.h PIR.c PIR.h US.c US.h usart.c usart.h
